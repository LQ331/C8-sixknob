# Keil uVision project C8-sixknob.uvprojx, settings and files
target C8-STM32F030 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: C8-sixknob-400  特调1 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F030x8
  c include: .\App;.\Module;.\Peripherals;.\User;.\Drivers\STM32F0xx_HAL_Driver\Inc;.\Drivers\STM32F0xx_HAL_Driver\Inc\Legacy;.\Drivers\CMSIS\Include;.\Drivers\CMSIS\Device\ST\STM32F0xx\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Drivers/CMSIS
    ./Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ./Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_cec.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_exti.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_irda.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_usart_ex.c stm32f0xx_hal_wwdg.c
  group Drivers/Startup
    ./Drivers/Startup/: startup_stm32f030x8.s
  group User
    ./User/: main.cpp stm32f0xx_callback.cpp stm32f0xx_hal_msp.cpp stm32f0xx_it.cpp
  group Peripherals
    ./Peripherals/: LGpio.cpp LUsart.cpp LTim.cpp LSpi.cpp LNvic.cpp LIwdg.cpp LDma.cpp LAdc.cpp
  group Module
    ./Module/: Coefficient.cpp Communication.cpp Led.cpp Sample.cpp Timer.cpp Flash.cpp keyboard.cpp Knob.cpp
  group App
    ./App/: Action.cpp AutoComm.cpp Device.cpp ElecParam.cpp Modbus.cpp Protect.cpp Protocol.cpp
software components: CMSIS:CORE 5.3.0
